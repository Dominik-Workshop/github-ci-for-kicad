# Repository Dominik-Workshop/github-ci-for-kicad

## KiCad design pcb/sec-pcb/pcb-sec.kicad_pcb

Parts:
J10: JST_B4B-XH-A; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J11: JST_B4P-VH; JST_VH_B4P-VH_1x04_P3.96mm_Vertical
J12: XT30; AMASS_XT30U-F_1x02_P5.0mm_Vertical

Connections:
/Rectifier/-DC: J12.1; also elsewhere on the board
/Rectifier/AC1: J11.4; also elsewhere on the board
/Series pass transistors/base: J10.4; also elsewhere on the board
/Series pass transistors/emitter: J12.2; also elsewhere on the board
/Tab selector/10V_AC: J11.3; also elsewhere on the board
/Tab selector/20V_AC: J11.2; also elsewhere on the board
/Tab selector/30V_AC: J11.1; also elsewhere on the board
/Tab selector/relay_1: J10.1; also elsewhere on the board
/Tab selector/relay_2: J10.2; also elsewhere on the board
/Tab selector/relay_VCC: J10.3; also elsewhere on the board

Notes on the sheet:
Second board

Parts:
D20, D21: BYG22B; D_SMA; MPN BYG22B-E3/TR
K20, K21: FINDER-40.41; Relay_SPDT_Finder_36.11

Connections:
/Rectifier/AC2: K20.11; also elsewhere on the board
/Tab selector/10V_AC: K21.12; also elsewhere on the board
/Tab selector/20V_AC: K21.14; also elsewhere on the board
/Tab selector/30V_AC: K20.14; also elsewhere on the board
/Tab selector/relay_1: D21.2 (A), K21.A1; also elsewhere on the board
/Tab selector/relay_2: D20.2 (A), K20.A1; also elsewhere on the board
/Tab selector/relay_VCC: D20.1 (K), D21.1 (K), K20.A2, K21.A2; also elsewhere on the board
unnamed: K20.12, K21.11

Notes on the sheet:
Tab selector
Second board

Parts:
C30, C31: 2200u; CP_Radial_D22.0mm_P10.00mm_SnapIn
D30, D31, D32, D33: MBR3045CT; TO-220-3_Horizontal_TabUp

Connections:
/Rectifier/+DC: C30.1, C31.1, D30.2 (A), D32.2 (A); also elsewhere on the board
/Rectifier/-DC: C30.2, C31.2, D31.1 (K), D31.3 (K), D33.1 (K), D33.3 (K); also elsewhere on the board
/Rectifier/AC1: D30.1 (K), D30.3 (K), D31.2 (A); also elsewhere on the board
/Rectifier/AC2: D32.1 (K), D32.3 (K), D33.2 (A); also elsewhere on the board

Notes on the sheet:
Rectifier
Second board

Parts:
Q40, Q42: BD249C; TO-247-3_Horizontal_TabUp
Q41, Q43: BD139; TO-126-3_Horizontal_TabUp
R40, R41: 0R2; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal

Connections:
/Rectifier/+DC: Q40.2 (C), Q41.2 (C), Q42.2 (C), Q43.2 (C); also elsewhere on the board
/Series pass transistors/base: Q41.3 (B), Q43.3 (B); also elsewhere on the board
/Series pass transistors/emitter: R40.2, R41.2; also elsewhere on the board
/Series pass transistors/pwr_e1: Q40.3 (E), R40.1
/Series pass transistors/pwr_e2: Q42.3 (E), R41.1
/Series pass transistors/pwr_eb1: Q40.1 (B), Q41.1 (E)
/Series pass transistors/pwr_eb2: Q42.1 (B), Q43.1 (E)

Notes on the sheet:
Series pass transistors
Second board

Board: 2 copper layers, 100.0 x 79.0 mm, 19 parts (10 on the bottom side), 17 nets.

## Commit log

2024-12-23 Add schematic pdf CI and gitignore for KiCad
2024-12-23 Add KiCad test project
2024-12-23 Add generated schematic PDF
2024-12-23 Add gerber job, with setup job installink KiCad once for both jobs
2024-12-23 Try fix CI
2024-12-23 Combine schematic and gerber generation
2024-12-23 Read project name in deploy job
2024-12-23 Fix export pdf command
2024-12-23 Remove validate job
2024-12-23 Add gerber files generation CI
2024-12-23 Test hardcode
2024-12-23 Add validate job, edit job triggers
2024-12-24 Zip gerber files
2024-12-24 Rename yml
2024-12-24 Correct drill file generation command
2024-12-24 Add generated schematic PDF and Gerber files
2024-12-24 Generate artifacts
2024-12-27 Generated with recommended hole generaton
2024-12-27 Generated with default hole generaton
2024-12-27 Generate blend from gerber files
2024-12-27 Combine pdf schematic, gerber files and PCB blend model generation
2024-12-27 Move test project to folder
2024-12-27 Finf project in folder
2024-12-27 Add second kicad test project
2024-12-28 Modify working directory, push changes directly to the repo
2024-12-28 Remove fab and doc directory from root
2024-12-28 Commit only necessary files, remove zip generation
2024-12-28 Fix gerber files selection to commit
2024-12-28 Add generated schematic PDF, necessary Gerber layers, and 3D model
